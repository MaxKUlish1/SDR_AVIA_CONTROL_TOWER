options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: filter_taps
    output_language: python
  states: {}

blocks:
- name: AUDIO
  id: variable_qtgui_range
  parameters:
    label: AUDIO
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: QWERTY
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0
    label: 'СЕЛЕКТОР:  '
    type: int
    value: variable_function_probe_0
  states: {}
- name: average_out
  id: variable
  parameters:
    value: int(samp_rate*4)
  states: {}
- name: bandwidwh
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: freq_1
  id: variable
  parameters:
    value: 115.4e6
  states: {}
- name: freq_2
  id: variable
  parameters:
    value: 118.3e6
  states: {}
- name: freq_3
  id: variable
  parameters:
    value: 119.1e6
  states: {}
- name: freq_4
  id: variable
  parameters:
    value: 119.4e6
  states: {}
- name: freq_5
  id: variable
  parameters:
    value: 121.7e6
  states: {}
- name: freq_6
  id: variable
  parameters:
    value: 126.8e6
  states: {}
- name: freq_7
  id: variable
  parameters:
    value: 131.4e6
  states: {}
- name: freq_hack_rf
  id: variable
  parameters:
    value: 125.4e6
  states: {}
- name: gui_1_0
  id: variable_qtgui_range
  parameters:
    label: Radio1
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.3'
  states: {}
- name: if_high_select_new
  id: variable_qtgui_range
  parameters:
    comment: |-
      в гну радио нет сравнения больше или равно,
      эта конастанта прибавляется к уровню шума
      для того чтобы с костылем выполнить эту операцию.
    label: порог отделяющий шум от сигнала, включающий селектор.
    start: '-5'
    step: '0.0001'
    stop: '5'
    value: '0.01'
  states: {}
- name: length_average_1
  id: variable
  parameters:
    value: int(samp_rate*15)
  states: {}
- name: rf_gain
  id: variable_qtgui_chooser
  parameters:
    label0: OFF RF AMPLIFIER
    label1: ON RF AMPLIFIER
    num_opts: '2'
    option0: '0'
    option1: '14'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.3e6
  states: {}
- name: scdd
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: 'base_band::'
    type: int
    value: int(text0*1000)
  states: {}
- name: scdd_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,1
    type: raw
    value: str(115.4)+ str({int(text1*1000)})+str(118.3)+str({int(text2*1000)})+str(119.1)+str({int(text3*1000)})+str(119.4)+str({int(text4*1000)})+str(121.7)+str({int(text5*1000)})+str(126.8)+str({int(text6*1000)})+str(131.4)+str({int(text7*1000)})
  states: {}
- name: text0
  id: variable_function_probe
  parameters:
    block_id: bl0
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text1
  id: variable_function_probe
  parameters:
    block_id: bl1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text2
  id: variable_function_probe
  parameters:
    block_id: bl2
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text3
  id: variable_function_probe
  parameters:
    block_id: bl3
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text4
  id: variable_function_probe
  parameters:
    block_id: bl4
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text5
  id: variable_function_probe
  parameters:
    block_id: bl5
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text6
  id: variable_function_probe
  parameters:
    block_id: bl6
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: text7
  id: variable_function_probe
  parameters:
    block_id: bl7
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: var_2
  id: variable
  parameters:
    value: '30'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '3'
    value: int(0)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '8'
    max_gain: '0'
    rate: '6.25e-4'
    reference: '0.3'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 6E3
    audio_stop: 8E3
    chan_rate: 48E3
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: gui_1_0
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: gui_1_0+if_high_select_new
    type: float
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: gui_1_0
    type: float
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_1
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_2
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_2_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_1
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: bl0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl2
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl3
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl4
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl5
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl6
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: bl7
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0_2
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0_2_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '8'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '100000'
    scale: '0.00001'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_2
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_0_2_0
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: int(length_average_1/var_2)
    max_iter: int((length_average_1/var_2)*100)
    scale: 1/(length_average_1/var_2)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_1_1
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_1_2
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_1_2_0
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2
  id: blocks_moving_average_xx
  parameters:
    length: length_average_1
    max_iter: length_average_1*100
    scale: 1/length_average_1
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0_2
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0_3
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_2_0_0_4
  id: blocks_moving_average_xx
  parameters:
    length: average_out
    max_iter: average_out*100
    scale: 1/average_out
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: AUDIO
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: int
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_function_probe_0
    num_inputs: '8'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_function_probe_0
    num_inputs: '8'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_2_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: gui_1_0+if_high_select_new
    init: '0'
    low: gui_1_0+if_high_select_new
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_2-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_3-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_4-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_5-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_6-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_2_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_7-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_1-freq_hack_rf
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 4e5
    win: window.WIN_RECTANGULAR
  states: {}
- name: note_0
  id: note
  parameters:
    note: для определения есть ли сигнал среди шума?
  states: {}
- name: note_1
  id: note
  parameters: {}
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: 2*22
    bw0: bandwidwh
    clock_source0: gpsdo
    corr0: '25'
    freq0: freq_hack_rf
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: 8*4
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidwh
    fc: '0'
    fftsize: '4096'
    name: SECOND_FILTER
    rate: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    gui_hint: 1,2
    label1: Float
    label2: Int
    name: Выбор argmax в данный момент.
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: int
    ymax: '10'
    ymin: '0'
    yunit: ''
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    color2: dark red
    color3: yellow
    color4: cyan
    grid: 'True'
    gui_hint: 1,1
    label1: AMPLITUDE_SELECT
    label2: NOISE_LEVEL & GAP_TO_SELECT_NEW
    label3: NOISE_LEVEL
    label4: МОЖНО ЛИ ПЕРЕКЛЮЧАТЬСЯ?
    name: Амплитуда + уровни. для сигнала {blocks_probe_signal_x_0}
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: int
    ymax: '10'
    ymin: '-3'
    yunit: ''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidwh
    fc: freq_hack_rf
    fftsize: '16384'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '4'
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_const_source_x_1, '0', bl0, '0']
- [analog_const_source_x_1, '0', blocks_argmax_xx_0, '0']
- [analog_const_source_x_1, '0', blocks_selector_0_1, '0']
- [analog_const_source_x_1_0, '0', qtgui_time_sink_x_0_0_1_0, '2']
- [analog_const_source_x_1_1, '0', qtgui_time_sink_x_0_0_1_0, '3']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [band_pass_filter_0_0_0_1, '0', blocks_complex_to_mag_squared_0_0_0_1, '0']
- [band_pass_filter_0_0_0_2, '0', blocks_complex_to_mag_squared_0_0_0_2, '0']
- [band_pass_filter_0_0_0_2_0, '0', blocks_complex_to_mag_squared_0_0_0_2_0, '0']
- [band_pass_filter_0_0_1, '0', blocks_complex_to_mag_squared_0_0_1, '0']
- [blocks_abs_xx_0_0, '0', blocks_moving_average_xx_0_0_0_2_0_0, '0']
- [blocks_abs_xx_0_0_0, '0', blocks_moving_average_xx_0_0_0_2_0_0_0, '0']
- [blocks_abs_xx_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_2_0_0_1, '0']
- [blocks_abs_xx_0_0_0_1, '0', blocks_moving_average_xx_0_0_0_2_0_0_2, '0']
- [blocks_abs_xx_0_0_0_2, '0', blocks_moving_average_xx_0_0_0_2_0_0_3, '0']
- [blocks_abs_xx_0_0_0_2_0, '0', blocks_moving_average_xx_0_0_0_2_0_0_4, '0']
- [blocks_abs_xx_0_0_1, '0', blocks_moving_average_xx_0_0_0_2_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_argmax_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_short_to_float_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_1_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_1, '0', blocks_moving_average_xx_0_0_0_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_0_1, '0', blocks_moving_average_xx_0_0_0_1_1, '0']
- [blocks_complex_to_mag_squared_0_0_0_2, '0', blocks_moving_average_xx_0_0_0_0_0_2, '0']
- [blocks_complex_to_mag_squared_0_0_0_2, '0', blocks_moving_average_xx_0_0_0_1_2, '0']
- [blocks_complex_to_mag_squared_0_0_0_2_0, '0', blocks_moving_average_xx_0_0_0_0_0_2_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_2_0, '0', blocks_moving_average_xx_0_0_0_1_2_0, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_moving_average_xx_0_0_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_moving_average_xx_0_0_0_2, '0']
- [blocks_float_to_char_0, '0', blocks_sample_and_hold_xx_0, '1']
- [blocks_float_to_int_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_moving_average_xx_0_0_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [blocks_moving_average_xx_0_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0, '1']
- [blocks_moving_average_xx_0_0_0_0_0_1, '0', blocks_sub_xx_0_0_0_1, '1']
- [blocks_moving_average_xx_0_0_0_0_0_2, '0', blocks_sub_xx_0_0_0_2, '1']
- [blocks_moving_average_xx_0_0_0_0_0_2_0, '0', blocks_sub_xx_0_0_0_2_0, '1']
- [blocks_moving_average_xx_0_0_0_0_1, '0', blocks_sub_xx_0_0_1, '1']
- [blocks_moving_average_xx_0_0_0_1, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_1_0, '0', blocks_sub_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0_1_1, '0', blocks_sub_xx_0_0_0_1, '0']
- [blocks_moving_average_xx_0_0_0_1_2, '0', blocks_sub_xx_0_0_0_2, '0']
- [blocks_moving_average_xx_0_0_0_1_2_0, '0', blocks_sub_xx_0_0_0_2_0, '0']
- [blocks_moving_average_xx_0_0_0_2, '0', blocks_sub_xx_0_0_1, '0']
- [blocks_moving_average_xx_0_0_0_2_0, '0', bl1, '0']
- [blocks_moving_average_xx_0_0_0_2_0, '0', blocks_argmax_xx_0, '1']
- [blocks_moving_average_xx_0_0_0_2_0, '0', blocks_selector_0_1, '1']
- [blocks_moving_average_xx_0_0_0_2_0_0, '0', bl2, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0, '0', blocks_argmax_xx_0, '2']
- [blocks_moving_average_xx_0_0_0_2_0_0, '0', blocks_selector_0_1, '2']
- [blocks_moving_average_xx_0_0_0_2_0_0_0, '0', bl3, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0_0, '0', blocks_argmax_xx_0, '3']
- [blocks_moving_average_xx_0_0_0_2_0_0_0, '0', blocks_selector_0_1, '3']
- [blocks_moving_average_xx_0_0_0_2_0_0_1, '0', bl4, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0_1, '0', blocks_argmax_xx_0, '4']
- [blocks_moving_average_xx_0_0_0_2_0_0_1, '0', blocks_selector_0_1, '4']
- [blocks_moving_average_xx_0_0_0_2_0_0_2, '0', bl5, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0_2, '0', blocks_argmax_xx_0, '5']
- [blocks_moving_average_xx_0_0_0_2_0_0_2, '0', blocks_selector_0_1, '5']
- [blocks_moving_average_xx_0_0_0_2_0_0_3, '0', bl6, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0_3, '0', blocks_argmax_xx_0, '6']
- [blocks_moving_average_xx_0_0_0_2_0_0_3, '0', blocks_selector_0_1, '6']
- [blocks_moving_average_xx_0_0_0_2_0_0_4, '0', bl7, '0']
- [blocks_moving_average_xx_0_0_0_2_0_0_4, '0', blocks_argmax_xx_0, '7']
- [blocks_moving_average_xx_0_0_0_2_0_0_4, '0', blocks_selector_0_1, '7']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0, '0']
- [blocks_sample_and_hold_xx_0, '0', blocks_float_to_int_0, '0']
- [blocks_sample_and_hold_xx_0, '0', qtgui_time_sink_x_0_0_1, '1']
- [blocks_selector_0, '0', analog_agc_xx_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0_0, '0']
- [blocks_selector_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_selector_0_1, '0', qtgui_time_sink_x_0_0_1_0, '1']
- [blocks_short_to_float_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_sub_xx_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', blocks_abs_xx_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0, '0', blocks_abs_xx_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0_1, '0', blocks_abs_xx_0_0_0_1, '0']
- [blocks_sub_xx_0_0_0_2, '0', blocks_abs_xx_0_0_0_2, '0']
- [blocks_sub_xx_0_0_0_2_0, '0', blocks_abs_xx_0_0_0_2_0, '0']
- [blocks_sub_xx_0_0_1, '0', blocks_abs_xx_0_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', band_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_selector_0, '2']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', band_pass_filter_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_selector_0, '3']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', band_pass_filter_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', blocks_selector_0, '4']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', band_pass_filter_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', blocks_selector_0, '5']
- [freq_xlating_fir_filter_xxx_0_0_0_2, '0', band_pass_filter_0_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_2, '0', blocks_selector_0, '6']
- [freq_xlating_fir_filter_xxx_0_0_0_2_0, '0', band_pass_filter_0_0_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_2_0, '0', blocks_selector_0, '7']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', band_pass_filter_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_selector_0, '1']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0_0, '0', blocks_throttle2_0, '0']
- [osmosdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
